<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\i2c_m.ewp</path>
    </project>
    <batchBuild />
</workspace>
